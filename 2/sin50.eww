<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup (2) of sin50.ewp</path>
    </project>
    <batchBuild />
</workspace>
